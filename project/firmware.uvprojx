# Keil uVision project firmware.uvprojx, settings and files
target firmware (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: firmware
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./Objects/@L.bin ./Objects/@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_ASSERT,DEBUG,ACU_TEST,SIM_ENV
  c include: ../src/include;../src/cmsis/inc;../src/driver/inc;../src/user/inc;../src/test/inc
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x20020000 size 0x8000
  group cmsis
    ../src/cmsis/src/: startup_acu.s system_acu.c
  group driver
    ../src/driver/src/: acu_debug.c acu_gpio.c acu_i2c.c acu_misc.c acu_rcc.c acu_spi.c acu_spi_flash.c acu_tim.c acu_uart.c acu_wdg.c
  group user
    ../src/user/src/: acu_it.c spi_flash.c test.c timer.c
    ../src/user/: main.c
  group test
    ../src/test/src/: test_cru.c test_gpio.c test_i2c.c test_spi.c test_spi_flash.c test_timer.c test_uart.c test_wdg.c
